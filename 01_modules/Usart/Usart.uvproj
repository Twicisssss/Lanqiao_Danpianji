# Keil uVision project Usart.uvproj, settings and files
target Usart (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Usart +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver;.\User
  group Driver
    ./Driver/: Init.c Init.h Key.c Key.h Led.c Led.h Seg.c Seg.h Uart.c Uart.h
  group User
    ./User/: main.c
