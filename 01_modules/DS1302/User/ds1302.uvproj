# Keil uVision project ds1302.uvproj, settings and files
target DS1302 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ds1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\System;..\User
  group User
    ./: main.c
  group Driver
    ../Driver/: Led.c Led.h Key.c Key.h Seg.c Seg.h
  group System
    ./: Init.c Init.h
    ../System/: ds1302.c ds1302.h
