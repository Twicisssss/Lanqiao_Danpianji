# Keil uVision project AT24C02.uvproj, settings and files
target AT24C02 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: AT24C02 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver;.\User
  group User
    ./User/: main.c
  group Driver
    ./Driver/: Init.c Init.h Key.c Key.h Led.c Led.h Seg.c Seg.h iic.c iic.h
