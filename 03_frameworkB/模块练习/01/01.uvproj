# Keil uVision project 01.uvproj, settings and files
target 01 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 01 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver;.\User
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group Driver
    ./Driver/: seg.c led.c key.c init.c ds1302.c onewire.c iic.c ultrasound.c uart.c
