# Keil uVision project scheduler.uvproj, settings and files
target scheduler (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: scheduler +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Source\Driver;..\Source\User
  group user
    ./: STARTUP.A51
    ../Source/User/: main.c
  group Driver
    ../Source/Driver/: ds1302.c ds1302.h iic.c iic.h init.c init.h key.c key.h led.c led.h onewire.c onewire.h seg.c seg.h ultrasound.c ultrasound.h usart.c usart.h
