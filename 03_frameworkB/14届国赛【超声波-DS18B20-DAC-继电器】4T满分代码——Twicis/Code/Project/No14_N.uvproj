# Keil uVision project No14_N.uvproj, settings and files
target No14_N (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: No14_N +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Source\Driver;..\Source\User
  group User
    ./: STARTUP.A51
    ../Source/User/: main.c
  group Driver
    ../Source/Driver/: iic.c init.c key.c led.c onewire.c seg.c ultrasound.c ultrasound.h
