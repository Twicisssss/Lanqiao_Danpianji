# Keil uVision project No15_P.uvproj, settings and files
target No15_P (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: No15_P +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Source\Driver;..\Source\User
  group User
    ./: STARTUP.A51
    ../Source/User/: main.c
  group Driver
    ../Source/Driver/: init.c key.c led.c seg.c ds1302.c iic.c
