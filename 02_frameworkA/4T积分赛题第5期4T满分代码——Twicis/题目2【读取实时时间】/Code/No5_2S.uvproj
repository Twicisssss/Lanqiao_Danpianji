# Keil uVision project No5_2S.uvproj, settings and files
target No5_2S (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: No5_2S +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver;.\User
  group Source Group 1
    ./: STARTUP.A51
  group User
    ./User/: main.c
  group Driver
    ./Driver/: ds1302.c ds1302.h Init.c Init.h Seg.c Seg.h Uart.c Uart.h Beeper.c Beeper.h
