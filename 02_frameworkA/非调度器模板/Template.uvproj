# Keil uVision project Template.uvproj, settings and files
target Template (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver;.\User
  group Source Group 1
    ./: STARTUP.A51
  group User
    ./User/: main.c
  group Driver
    ./Driver/: Init.c Init.h Key.c Key.h Led.c Led.h Seg.c Seg.h ds1302.c ds1302.h onewire.c onewire.h iic.c iic.h
