# Keil uVision project No14_M2.uvproj, settings and files
target No14_M2 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: No14_M2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver;.\User
  group Source Group 1
    ./: STARTUP.A51
  group User
    ./User/: main.c
  group Driver
    ./Driver/: iic.c iic.h Init.c Init.h Key.c Key.h Led.c Led.h onewire.c onewire.h Seg.c Seg.h Uart.c Uart.h
